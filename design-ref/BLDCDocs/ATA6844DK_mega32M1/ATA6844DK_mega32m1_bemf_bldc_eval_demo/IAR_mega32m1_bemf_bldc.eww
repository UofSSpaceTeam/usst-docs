<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR_mega32m1_bemf_bldc.ewp</path>
  </project>
  <batchBuild/>
</workspace>


